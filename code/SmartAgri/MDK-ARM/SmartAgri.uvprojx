# Keil uVision project SmartAgri.uvprojx, settings and files
target SmartAgri (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: SmartAgri +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --diag_suppress=1,177,550
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../APP/Inc;../BSP/Inc;../Driver/Inc;../Service/Inc;../Common/Inc
  asm include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group APP
    ../APP/Src/: app_data.c app_task_ctrl.c app_task_net.c app_task_sensor.c app_task_ui.c
  group Driver
    ../Driver/Src/: drv_bh1750.c drv_esp8266.c drv_oled.c drv_oled_data.c drv_rain_adc.c drv_sht30.c drv_soil_adc.c
  group Service
    ../Service/Src/: svc_alarm.c svc_net.c svc_ui.c
  group BSP
    ../BSP/Src/: bsp_buzz.c bsp_key.c bsp_led.c bsp_log.c
software components: CMSIS:CORE 4.3.0
